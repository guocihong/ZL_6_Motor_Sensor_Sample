# Keil uVision project ZL_6_Motor_Sensor_Sample.uvproj, settings and files
target Sample (MCS-51)
  device: STC12C5A32S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: 6道电机控制杆主程序-设置平均点数 +hex
  c flags: Optimize=7 SizeSpeed=1
  group system
    ./: STARTUP.A51 main.c system_init.c variable.c
  group task
    ./task/uart/: uart_task.c
    ./task/doorkeep/: doorkeep_task.c
    ./task/motor/: motor_task.c
    ./task/adc/: adc_task.c
  group drive
    ./driver/timer/: timer_drv.c
    ./driver/uart/: uart_drv.c
    ./driver/adc/: adc_drv.c
    ./driver/flash/: flash_drv.c
